# Keil uVision project KJ109-101.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8447 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0x6FF) CLOCK(16000000)
  output: KJ109-101 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc;.\lib
  group Source Group 1
    ./: STARTUP.A51
    ./lib/: S_TouchKeyCFG.C SC92F8X4X_HighSensitive_Lib_T1_V1.1.0.LIB
    ./src/: eeprom.c fan.c filter.c ion.c key.c led.c main.c dust.c arom.c timing_off.c beep.c
